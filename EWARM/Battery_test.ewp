# IAR project Battery_test.ewp, settings and files
configuration Battery_test (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103RB ST STM32F103RB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xB
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Drivers/CMSIS/Include; ..\bsp; ..\user; ..\Drivers; ..\Drivers\Embedded_GUI_Library\inc; ..\Drivers\Embedded_GUI_HAL\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Battery_test.bin
  ILINK.IlinkOutputFile: Battery_test.out
  ILINK.IlinkIcfFile: stm32f103xb_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/bsp
    ../bsp/: bsp.c bsp.h stm32f1xx_it.c system_stm32f1xx.c
  group Application/EWARM
    ./: startup_stm32f103xb.s
  group Application/User
    ../Src/: main.c
  group Application/User/charger
    ../user/charger/: charger.c charger.h
  group Application/User/logger
    ../user/logger/: logger.c logger.h
  group Drivers/Embedded_GUI_HAL
    ../Drivers/Embedded_GUI_HAL/src/: LcdHal.c
  group Drivers/Embedded_GUI_Library
    ../Drivers/Embedded_GUI_Library/src/: cursor.c gl_fonts.c gl_testFonts.c graphicObject.c images.c
  group Drivers/fs_fat
    ../Drivers/fs_fat/: fat_access.c fat_access.h fat_cache.c fat_cache.h fat_defs.h fat_filelib.c fat_filelib.h fat_format.c fat_format.h fat_list.h fat_misc.c fat_misc.h fat_opts.h fat_string.c fat_string.h fat_table.c fat_table.h fat_types.h fat_write.c fat_write.h
  group Drivers/lcd
    ../Drivers/lcd_driver/: ili9320.c ili9320.h ili9320_font.h
  group Drivers/mmc_sd
    ../Drivers/mmc_sd/: mmc_sd.c mmc_sd.h
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/touch
    ../Drivers/touch_Driver/: touch_tsc2046.c
